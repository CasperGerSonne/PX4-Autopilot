## src/modules/iot/Kconfig
```kconfig
menuconfig MODULES_IOT
	bool "iot"
	default n
	---help---
		Enable support for iot
```
